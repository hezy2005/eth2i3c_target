# IAR project eth2i3c_target.ewp, settings and files
configuration eth2i3c_target (ARM, debug)
  General.OGChipSelectEditMenu: STM32H563ZI ST STM32H563ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=8000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; EXTERNAL_CLOCK_VALUE=12288000; HSI_VALUE=64000000; LSI_VALUE=32000; VDD_VALUE=3300; PREFETCH_ENABLE=0; ART_ACCELERATOR_ENABLE=0; STM32H563xx
  ICCARM.CCIncludePath2: ../Inc; ../../common/Drivers/STM32H5xx_HAL_Driver/Inc; ../../common/Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../common/Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: eth2i3c_target.hex
  ILINK.IlinkOutputFile: eth2i3c_target.out
  ILINK.IlinkIcfFile: stm32h563xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h563xx.s
  group Application/User
    ../Src/: main.c stm32h5xx_it.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../common/Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_ll_dma.c stm32h5xx_ll_exti.c stm32h5xx_ll_gpio.c stm32h5xx_ll_i3c.c stm32h5xx_ll_icache.c stm32h5xx_ll_pwr.c stm32h5xx_ll_rcc.c stm32h5xx_ll_utils.c
